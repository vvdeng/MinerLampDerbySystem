# Keil uVision project stc15_infra_12864_test.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: stc15_infra_12864_test +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: config.c eeprom.c main.c useful.c hanzi.c lcd12864.c vvspi.c
