# Keil uVision project stc_terminal_v01.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC15F2K60S2 STC
  cpu: IRAM(0-0xFF) XRAM(0-0x6FF) IROM(0-0xEFF8) CLOCK(35000000) MODP2
  output: stc_terminal_v01 +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: hanzi.c insideStorage.c lcd12864.c main.c vvspi.c useful.c config.c yuyin.c
